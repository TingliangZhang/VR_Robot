# Keil uVision project DobotDemo.uvprojx, settings and files
target DobotDemo (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DobotDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\src\STLIB\inc;.\src\STM32F10X;.\src\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./src/APP/: main.cpp command.cpp command.h
  group driver
    ./src/driver/: usart.c usart.h systick.c systick.h
  group core
    ./src/CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group stlib
    ./src/STLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group stm32f10x
    ./src/STM32F10X/: stm32f10x_it.c system_stm32f10x.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group complatform
    ./src/ComPlatform/: Message.cpp Message.h Packet.cpp Packet.h ProtocolDef.h RingBuffer.cpp RingBuffer.h Protocol.cpp Protocol.h ProtocolID.h
